# Keil uVision project Apex.uvprojx, settings and files
target Apex (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Apex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,ARM_MATH_CM3
  c misc: --cpp11;
  c include: ../Inc;          ../Drivers/STM32F1xx_HAL_Driver/Inc;          ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;          ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;          ../Drivers/CMSIS/Include;          ..\Interaction;          ..\Kernel
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_spi.c stm32f1xx_hal_gpio.c stm32f1xx_hal_uart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: stm32f1xx_it.c stm32f1xx_hal_msp.c main.c
  group Interaction
    ../Interaction/: button.cpp button.h is.cpp is.h oled.c oled.h oled_form.h stockpile.c stockpile.h ui.cpp ui.h usart_txrx.c usart_txrx.h
  group Kernel
    ../Kernel/: as5048.cpp as5048.h controller.cpp controller.h loop.cpp loop.h sin_form.h
  group DSP_Lib_152
    ../Lib/DSP/152/: arm_cortexM3l_math.lib
  group DSP_Lib_145
    ../Lib/DSP/145/: arm_cortexM3l_math.lib
software components: CMSIS:CORE 4.3.0
